Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2019-04-15T19:29:16
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Apr 15 19:29:16 2019 * Host: DEGTL09122 * Database: C:\Users\deschvi\AppData\Local\Temp\{569FF6EE-C0C6-41FB-AC06-0AEE87D4E30D}\ifc * Database version: 5507 * Database creation date: Mon Apr 15 19:29:15 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Apr 15 19:29:16 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Apr 15 19:29:16 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 22726434_D_11104200_H7264B_GRGR, 11104200_D_H7264B_GRGR:22726434_D_11104200_H7264B_GRGR:205912
In: Level 1
Type - Classification: H7000 B (Uniformat); Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_GRGR, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel
Pset_BuildingElementProxyCommon - Reference: 22726434_D_11104200_H7264B_GRGR
Pset_ManufacturerTypeInformation - Manufacturer: Miele
